# Keil uVision project WaterProject.uvproj, settings and files
target WaterProject (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: WaterProject +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Protocol;..\Mode\inc;..\MyLib\inc;..\Lib\inc;..\User
  group Mode
    ../Mode/src/: PrivateMode.c PublicFunction.c PublicMode.c
  group MyLib
    ../MyLib/src/: Gprs.c Usart.c Delay.c IODeal.c Timer.c EEPROM.c
  group Main
    ./: STARTUP.A51
    ../User/: main.c
  group Protocol
    ../Protocol/: Packet.c
